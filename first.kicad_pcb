# Repository ramunecyudokusha/stm_25v1_board

File README.md:

# stm_25v1_board
stm32f446が乗った基板を開発する
# 開発品(随時更新)

# 目次
基板の概要
各基板の機能
ピン割り当て
#

## KiCad design first.kicad_pcb

Parts:
C1: 22μF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C3: 4.7μF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4, C5: 0.1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6, C7, C10, C11, C12: 0.1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C8: 1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C9: 0.1uf; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C13: 4.7μF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C14: 4.7uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: LED_RED; D_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D2: D_Shockley; D_SOD-323_HandSoldering
D3: LED_YELLOW; D_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D4: LED_GREEN; D_0805_2012Metric_Pad1.15x1.40mm_HandSolder
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J3, J7: Conn_01x02_Socket; JST_XH_S2B-XH-A-1_1x02_P2.50mm_Horizontal
J2: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J4, J8, J9, J10, J11, J12, J13, J14: Conn_01x03_Socket; JST_XH_S3B-XH-A-1_1x03_P2.50mm_Horizontal
J5: Conn_01x02_Socket; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
J6: Conn_ST_STDC14; IDC-Header_2x07_P2.54mm_Vertical
R1, R2: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4, R5, R6: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_Wuerth_450301014042; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm
SW2: SW_Push; SW_PUSH_6mm
U1: BD33FC0FP; TO-252-2
U2: STM32F446RETx; LQFP-64_10x10mm_P0.5mm
U3: MCP2562-E-P; DIP-8_W7.62mm

Connections:
+3.3V: C1.1, C3.1, C6.1, C7.1, C8.2, C9.2, C10.1, C11.1, C12.1, C14.1, D2.2 (A), J6.3 (VCC), U1.3 (VO), U2.1 (VBAT), U2.13 (VDDA), U2.19 (VDD), U2.32 (VDD), U2.48 (VDD), U2.64 (VDD), U3.5 (Vio)
+5V: C2.1, C4.1, D1.2 (A), D2.1 (K), J1.2, J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), J3.2, J5.2, U1.1 (VCC), U3.3 (VDD)
CAN1rx: U2.61 (PB8), U3.4 (RXD)
CAN1tx: U2.62 (PB9), U3.1 (TXD)
CANR: R4.2, SW1.3 (A)
CAN_H: J4.3, SW1.1 (B), U3.7 (CANH)
CAN_L: J4.2, R4.1, U3.6 (CANL)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.1, C10.2, C11.2, C12.2, C13.1, C14.2, J1.1, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J3.1, J4.1, J5.1, J6.5 (GND), J6.7 (GND), J8.3, J9.3, J10.3, J11.3, J12.3, J13.3, J14.3, R1.2, R2.2, R3.2, R5.1, R6.1, SW2.2, U1.2 (GND), U2.12 (VSSA), U2.18 (VSS), U2.31 (VSS), U2.47 (VSS), U2.63 (VSS), U3.2 (VSS), U3.8 (STBY)
unnamed: D1.1 (K), R3.1
unnamed: D3.2 (A), U2.11 (PC3)
unnamed: D3.1 (K), R5.2
unnamed: D4.2 (A), U2.10 (PC2)
unnamed: D4.1 (K), R6.2
unnamed: J2.A5 (CC1), R2.1
unnamed: J2.B5 (CC2), R1.1
unnamed: C5.1, SW2.1, U2.7 (NRST)
unnamed: C13.2, U2.30 (VCAP_1)
m1: J9.2, U2.16 (PA2)
m1d: J9.1, U2.15 (PA1)
m2: J10.2, U2.21 (PA5)
m2d: J10.1, U2.20 (PA4)
m3: J12.2, U2.23 (PA7)
m3d: J12.1, U2.22 (PA6)
m4: J13.2, U2.26 (PB0)
m4d: J13.1, U2.25 (PC5)
m5: J14.2, U2.28 (PB2)
m5d: J14.1, U2.27 (PB1)
m6: J11.2, U2.34 (PB13)
m6d: J11.1, U2.33 (PB12)
m7: J8.2, U2.36 (PB15)
m7d: J8.1, U2.35 (PB14)
outputGND: J6.11 (GNDDetect)
strx: J6.13 (VCP_RX), U2.52 (PC11)
sttx: J6.14 (VCP_TX), U2.51 (PC10)
swclk: J6.6 (JCLK/SWCLK), U2.49 (PA14)
swdio: J6.4 (JTMS/SWDIO), U2.46 (PA13)
swo: J6.8 (JTDO/SWO), U2.55 (PB3)
uart4rx: J7.2, U2.43 (PA10)
uart4tx: J7.1, U2.42 (PA9)

Notes on the sheet:
終端抵抗オンオフ
電源コネクタ XT30
3.3v変圧+逆流防止回路
5v供給用xh端子
STlink,電源供給usbC
CANトランシーバー
モーター用出力
リセット用スイッチ

Board: 2 copper layers, 60.0 x 100.0 mm, 47 parts (0 on the bottom side), 38 nets.

## KiCad design second.kicad_pcb

Board: 2 copper layers, 55.0 x 100.0 mm, 48 parts (0 on the bottom side), 38 nets.

Parts:
C1, C11, C12, C13: 0.1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2: 4.7μF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C4, C5, C6, C8: 0.1μF; C_0201_0603Metric_Pad0.64x0.40mm_HandSolder
C7: 4.7uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C9: 0.1uf; C_0201_0603Metric_Pad0.64x0.40mm_HandSolder
C10: 1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C14, C16: 4.7μF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C15: 22μF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: LED_GREEN; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D2: D_Shockley; D_SOD-882
D4: LED_RED; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J13, J14: Conn_01x02_Socket; JST_XH_S2B-XH-A-1_1x02_P2.50mm_Horizontal
J2, J3, J4, J5, J6, J7, J8, J9, J12: Conn_01x03_Socket; JST_XH_S3B-XH-A-1_1x03_P2.50mm_Horizontal
J10: Conn_01x02_Socket; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
J11: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
R1: 120; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R3: 75; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R5: 5.1k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
SW1: SW_Push; SW_PUSH_6mm
SW3: SW_Wuerth_450301014042; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm
U1: STM32F446RETx; LQFP-64_10x10mm_P0.5mm
U2: MCP2561-E-SN; SOIC-8_3.9x4.9mm_P1.27mm
U3: CH340E; MSOP-10_3x3mm_P0.5mm
U4: BD33FC0FP; TO-252-2

Connections:
+3.3V: C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.2, C10.2, C15.1, C16.1, D2.2 (A), U1.1 (VBAT), U1.13 (VDDA), U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD), U4.3 (VO)
+5V: C11.1, C12.2, C14.1, D2.1 (K), D4.2 (A), J10.2, J11.A4 (VBUS), J11.A9 (VBUS), J11.B4 (VBUS), J11.B9 (VBUS), J13.2, J14.2, U2.3 (VDD), U3.7 (VCC), U4.1 (VCC)
CAN1rx: U1.44 (PA11), U2.4 (RXD)
CAN1tx: U1.45 (PA12), U2.1 (TXD)
CANR: R1.2, SW3.3 (A)
CAN_H: J12.3, SW3.1 (B), U2.7 (CANH)
CAN_L: J12.1, R1.1, U2.6 (CANL)
D+: J11.A6 (D+), J11.B6 (D+), U3.1 (UD+)
D-: J11.A7 (D-), J11.B7 (D-), U3.2 (UD-)
GND: C1.2, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.1, C10.1, C11.2, C12.1, C13.2, C14.2, C15.2, C16.2, J2.3, J3.3, J4.3, J5.3, J6.3, J7.3, J8.3, J9.3, J10.1, J11.A1 (GND), J11.A12 (GND), J11.B1 (GND), J11.B12 (GND), J12.2, J13.1, J14.1, R2.2, R3.2, R4.2, R5.2, SW1.2, U1.12 (VSSA), U1.18 (VSS), U1.31 (VSS), U1.47 (VSS), U1.63 (VSS), U2.2 (VSS), U2.8 (STBY), U3.3 (GND), U4.2 (GND)
unnamed: D1.2 (A), U3.6 (TNOW)
unnamed: D1.1 (K), R2.1
unnamed: D4.1 (K), R3.1
unnamed: J11.A5 (CC1), R5.1
unnamed: J11.B5 (CC2), R4.1
unnamed: C1.1, SW1.1, U1.7 (NRST)
unnamed: C2.2, U1.30 (VCAP_1)
unnamed: C13.1, U3.10 (V3)
UARTrx: U1.17 (PA3), U3.8 (TXD)
UARTtx: U1.16 (PA2), U3.9 (RXD)
m1: J2.2, U1.21 (PA5)
m1d: J2.1, U1.2 (PC13)
m2: J3.2, U1.22 (PA6)
m2d: J3.1, U1.3 (PC14)
m3: J4.2, U1.55 (PB3)
m3d: J4.1, U1.4 (PC15)
m4: J5.2, U1.57 (PB5)
m4d: J5.1, U1.46 (PA13)
m5: J6.2, U1.29 (PB10)
m5d: J6.1, U1.49 (PA14)
m6: J7.2, U1.43 (PA10)
m6d: J7.1, U1.50 (PA15)
m7: J8.2, U1.27 (PB1)
m7d: J8.1, U1.59 (PB7)
m8: J9.2, U1.26 (PB0)
m8d: J9.1, U1.10 (PC2)
uart4rx: J1.2, U1.15 (PA1)
uart4tx: J1.1, U1.14 (PA0)

## Commit log

2025-12-21 first of all
2025-12-21 通知テスト
2025-12-21 フットプリントの割り当てと一部コンデンサの容量の変更 電コンとショッキーダイオードの選定が終わっていない
2025-12-21 Update README.md
    描こうと思ったけどねむい
2025-12-22 Create パーツ.md
    create page and writing
    unfinished
2025-12-22 回路図を描き終えた
2025-12-22 add netlist
2025-12-22 pcbの配置のみを行った 配線は地獄
2025-12-22 Add files via upload
    フリールーティングの実験を行った
    電源回りの配線は手動で行う必要あり
2025-12-23 次のコミット時に記入
2025-12-23 回路図の一部素子の変更、削除。pcbの電源回りの配線
2025-12-23 Add files via upload
    3回目のフリールーティングによる生成ファイルの追加(ベタ島の改善の必要性あり)
2025-12-23 Update README.md
    add picture
2025-12-23 電源回りの配線の改良(third.pcbの元ファイル)
2025-12-24 Update パーツ.md
    通販URLの追加。各部品との結び付け未完了
2026-01-17 autoroutingで全体を配線した
2026-01-17 DRCの実行、gndベタの最適化
2026-01-21 mcpモジュールの変更、stlinkV3の追加
2026-01-22 canモジュールの配線の変更、UART書き込み回路の削除
2026-01-23 デバッグ用LEDの追加,モーター用出力の追加など
2026-01-23 回路図の微調整、pcbエディターでの配線、完成版ver1
2026-01-24 PCBAの仕様に沿った部品に変更、再配置
2026-01-25 stdc14のコネクタをきちんとしたものに取り換え、5V供給端子のループを解消
2026-05-14 完成品をmainに移す
